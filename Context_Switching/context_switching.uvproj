# Keil uVision project context_switching.uvproj, settings and files
target Lab1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: context_switching
  c flags: Optim=1
  c define: DEBUG_0
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s
  group System Code
    ./src/: system_LPC17xx.c
  group Kernel
    ./src/: memoryBlock.h HAL.c k_memory.c k_memory.h k_process.c k_process.h k_rtx.h k_rtx_init.c k_rtx_init.h main_svc.c rtx.h uart_polling.c uart_polling.h Timer.c Timer.h msg.c msg.h
  group utilities
    ./src/: printf.c printf.h stress.c stress.h generic_queue.c generic_queue.h
  group user
    ./src/: usr_proc.c usr_proc.h
